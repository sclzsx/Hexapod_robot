# Keil uVision project hexapod_robot.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hexapod_robot +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\FWlib\inc;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c usart1.c SysTick.c stm32f10x_it.c timer_count.c adc.c gpio.c ultrasonic.c 24l01.c lcd.c OLED.c spi.c sys.c
  group startup
    ../CMSIS/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_iwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
